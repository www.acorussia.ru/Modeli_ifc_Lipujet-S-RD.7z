Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView, QuantityTakeOffAddOnView]
Time: 2017-05-23T10:12:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 23 10:12:56 2017 * Host: IN-BLR-PC-0012 * Database: C:\Users\palleri\AppData\Local\Temp\{1B694116-F9A3-4E0F-9084-71A7F16939CF}\ifc * Database version: 5507 * Database creation date: Tue May 23 10:12:55 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 23 10:12:55 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 23 10:12:55 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Identity Data - Type Name: Level 1; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowController: std, ZZZ_do not use_ME_ST_filling device for Lipurex_ACO:std:15088
In: Level 1
Type - Description: Filling device; PredefinedType: FAUCET; Material: Stainless Steel, Brushed
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC010071; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_P_c01_diameter: 20 mm
Type - Identity Data - Description: Filling device; LOD: LOD 400; Manufacturer: ACO; Model: ACO filling device for Lipurex; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Free outlet as per DIN 1988 Part 4; Type Name: std
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO
Type - Plumbing - p_c01_flow: 0.105944 m3/s
Type - Structural - RSen_S_net_mass: 2.3
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std
Constraints - Moves With Nearby Elements: no; Offset: 1615.5 mm
Dimensions - Area: 0.0761672 m2; Volume: 0.00141803 m3
General - RSen_C_intended_use: Entwässerungssysteme
Identity Data - Mark: 15; RSen_C_code_article: 7602.00.25; RSen_C_code_gtin: 04002626143303; RSen_C_description: ACO Fülleinheit für Lipurex-O,-OD,-R,-RD
Other - option: 1; Family: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO: std; Family and Type: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO: std; Type: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO: std; Type Id: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO: std
Phasing - Phase Created: New Construction

# IfcFlowTerminal: NS4, ME_ST_lipurex rd extension stage 1_ACO:NS4:15082
In: Level 1
Type - Description: Grease separator plant as per DIN EN 1825 and DIN 4040-100; PredefinedType: GREASEINTERCEPTOR; Material: Stainless Steel, Brushed
Type - General - instructions_for_use: http://katalog.aco-haustechnik.de/ilcatalogue/download/ZG9jdW1lbnQvZG93bmxvYWQucGRmL2RlL0VCQV9GQV9GcmVpYXVmc3RlbGx1bmdfcnVuZF91bmRfb3ZhbF9fNDUwMDUucGRm/EBA_FA_Freiaufstellung_rund_und_oval__45005.pdf; RSen_C_code_ETIM: EC010271; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_info_technical: http://katalog.aco-haustechnik.de/Home/Produkte/Clean/Fettabscheider/Freiaufstellung/Vollentsorgung/Runde-Bauform-Edelstahl-1.4571/Lipurex-RD-Ausbaustufe-1; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: Grease separator plant as per DIN EN 1825 and DIN 4040-100; LOD: LOD 400; Manufacturer: ACO; Model: NS 4; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Building Supervisory Authority approval Z-54.1-414; Type Name: NS4
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; extension_stage_lookup_table_name: lipurex_rd_extension_stage_1; Family Name: ME_ST_lipurex rd extension stage 1_ACO
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: NS4
Constraints - clearance_zone: no; DN_sanitary: yes; filling_device: yes; grease_measure_device: no; heating_rod: no; inlet_angle: 0 deg; left: no; logo: yes; OD_sanitary: no; Offset: 0 mm; right: yes; sight_glass: no
Dimensions - Area: 13.9324 m2; D: 110 mm; D1: 1000 mm; DN: 100 mm; H: 1402.5 mm; H1: 1240 mm; H2: 1170 mm; H3: 1450 mm; H4: 1770 mm; L1: 1180 mm; L2: 120 mm; L3: 150 mm; vent_DN: 70 mm; Volume: 0.000562494 m3
General - RSen_P_c01_diameter: 100 mm; RSen_P_c02_diameter: 100 mm; RSen_P_c03_diameter: 70 mm; RSen_P_c04_diameter: 20 mm; RSen_P_c05_diameter: 65 mm
Identity Data - Mark: 13; RSen_C_code_article: 7504.62.00; RSen_C_code_gtin: 04002626141866; RSen_C_description: ACO Fettabscheid. Lipurex RD NS4 m. Dir.absaug. rund
Mechanical - RSen_P_c04_flow: 0 m3/s; System Classification: Sanitary,Vent,Domestic Cold Water,Other
Model Properties - clearance_back: 640 mm; clearance_entry: 1590 mm; clearance_exit: 690 mm; clearance_front: 1190 mm; clearance_top: 2370 mm; D_drain: 76 mm; DN_drain: 65 mm; drain_X: 200 mm; drain_Y: 653.59 mm; drain_Z: 1526.5 mm
Other - cold_water_connector: cw in; connector_escape_message: Nicht verwenden; Family: ME_ST_lipurex rd extension stage 1_ACO: NS4; Family and Type: ME_ST_lipurex rd extension stage 1_ACO: NS4; L2_half: 60 mm; lookup_table_name: lipurex_r_basic; no_option: 0; option: 1; options_lookup_table_name: lipurex_r_options; R: 55 mm; R1: 500 mm; Type: ME_ST_lipurex rd extension stage 1_ACO: NS4; Type Id: ME_ST_lipurex rd extension stage 1_ACO: NS4
Phasing - Phase Created: New Construction
Plumbing - grease_store_capacity: 0.165 m3; overall_capacity: 0.915 m3; sludge_trap_capacity: 0.42 m3
Structural - RSen_S_gross_mass: 1101; RSen_S_net_mass: 186

# IfcFlowTerminal: std, ZZZ_do not use_ME_ST_lipurex_r_options_ACO:std:15083
In: Level 1
Type - PredefinedType: GREASEINTERCEPTOR; Material: Plastic, White, HDPE, Red, Stainless Steel, Brushed
Type - Identity Data - Manufacturer: Aco; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Name: std
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_ST_lipurex_r_options_ACO
Pset_ManufacturerTypeInformation - Manufacturer: Aco
Pset_DistributionFlowElementCommon - Reference: std
Constraints - filling_device: yes; grease_measure_device: no; heating_rod: no; inlet_angle: 0 deg; left: no; logo: yes; Offset: 0 mm; right: yes; sight_glass: no; Moves With Nearby Elements: no
Dimensions - acces_exit_X_pos: 250 mm; access_entry_diameter: 327 mm; access_entry_X_position: 250 mm; Area: 6.54619 m2; bottom_diam: 280 mm; bottom_length: 223 mm; bottom_offset: 20.5 mm; cover_Z_position: 1440.5 mm; D: 110 mm; D1: 1000 mm; disposalpump_angle: 30 deg; disposalpump_flange_OD: 220 mm; disposalpump_flange length: 23.5 mm; disposalpump_OD: 114.3 mm; disposalpump_X: 635 mm; disposalpump_Z: 135.5 mm; DN: 100 mm; footing_radius: 545 mm; glass_Z_position: 1094.5 mm; glasstube_diam: 336 mm; glasstube_length: 1000 mm; H: 1402.5 mm; H1: 1240 mm; H2: 1170 mm; H3: 1450 mm; H4: 1770 mm; inlet_length: 600 mm; L1: 1180 mm; L2: 120 mm; L3: 150 mm; leg_offset: 90 deg; legnumber: 3; logo_Z: 591 mm; outlet_length: 600 mm; rib_diameter: 1028.5 mm; rib_number: 1; rib_thickness: 35 mm; rib1_Z: 724.5 mm; rib2_Z: 100 mm; vent_DN: 70 mm; vent_OD: 75 mm; vent_X: 200 mm; vent_Y: 1346.4 mm; Volume: 1.06119 m3; waterinlet_angle: -20 deg; waterinlet_OD: 76.1 mm; waterinlet_X: 585 mm; waterinlet_Z: 1340.5 mm
General - RSen_P_c01_diameter: 100 mm; RSen_P_c02_diameter: 100 mm
Identity Data - Mark: 14
Model Properties - glass_position: 90 deg; glass_X_position: 498 mm; grease_measure_end_angle: 265 deg; grease_measure_start_angle: 270 deg; grease_measure_X: 0.1 mm; grease_measure_Y: 1150 mm; grease_measure_Z: 1402.5 mm; heatrod_position: 90 deg; heatrod_Z_position: 794.5 mm
Other - blend_position: 243.5 mm; bottom_plate: no; Family: ZZZ_do not use_ME_ST_lipurex_r_options_ACO: std; Family and Type: ZZZ_do not use_ME_ST_lipurex_r_options_ACO: std; filling_device_option: 1; grease_measure_option: 1; heatrod_option: 1; L2_half: 60 mm; logo_position: 90 deg; lookup_table_name: lipurex_r_basic; options_lookup_table_name: lipurex_r_options; R: 55 mm; R1: 500 mm; sight_glass_option: 1; Type: ZZZ_do not use_ME_ST_lipurex_r_options_ACO: std; type_index: 4; Type Id: ZZZ_do not use_ME_ST_lipurex_r_options_ACO: std; vent_length: 50 mm; waterinlet_end_angle: 25 deg; waterinlet_height: 275 mm; waterinlet_start_angle: 20 deg
Phasing - Phase Created: New Construction
